HEC-RAS study Four Hole Swamp.prj: Four Hole Swamp Limited Detail Study

--- Four Hole Swamp.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,120196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 138.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2118801.78       578993.17      2116421.63       578554.12
      2113524.96       578024.99
#Sta/Elev= 30
  2579.7  127.69  2739.7  123.04  2799.7  123.39  2889.7  126.48  3059.7  127.36
  3129.7  127.32  3269.7  122.89  3609.7  123.31  3629.7  124.88  3669.7  111.11
  3699.7  109.43  4009.7   107.1  4029.7  108.01  4039.7   106.4  4219.7  105.19
  4819.7  106.07  4953.4     105  4955.9     100  5044.1     100  5046.6     105
    5720   105.2    5800  106.54    5970  105.13    6090  106.07    6700     105
    6970  113.33    7020  117.14    7330  120.43    7510  127.16  7944.6  136.55
#Mann= 3 ,-1 , 0
  2579.7    .145       0  4953.4     .05       0  5046.6    .145       0
Bank Sta=4953.4,5046.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,119196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 137.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2119264.03       578028.18      2116709.52        577602.7
       2113555.2       577055.09
#Sta/Elev= 30
  2410.3  137.99  2450.3  139.17  2680.3  134.83  2950.3  135.38  3350.3  136.87
  3580.3  140.43  3660.3  138.46  3880.3  124.62  3980.3  113.95  4080.3  106.22
  4300.3   104.7  4790.3  104.77  4890.3  106.24  4953.4  104.54  4955.9   99.54
  5044.1   99.54  5046.6  104.54    5160  105.77    6050   104.8    6250  106.45
    6290  105.02    6870  105.49    6940  115.18    7040  118.84    7400  120.07
    7450  121.81    7570  120.47    7750  122.84    7890  127.23  8201.5  130.69
#Mann= 3 ,-1 , 0
  2410.3    .145       0  4953.4     .05       0  5046.6    .145       0
Bank Sta=4953.4,5046.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,118196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 136.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2119069.45       576682.06      2116907.75       576678.38
      2113814.65       576682.06
#Sta/Elev= 30
  2838.3  139.16  2888.3  141.24  2948.3  140.39  3118.3  133.34  3358.3  127.37
  3408.3  122.97  3568.3  121.39  3638.3  118.57  3738.3  117.85  3788.3  115.22
  4278.3  107.65  4358.3  104.03  4698.3  103.87  4828.3  105.49  4953.4  103.73
  4955.9   98.73  5044.1   98.73  5046.6  103.73    5520  104.14    5550  105.86
    5680  104.73    5720  106.12    5770  104.31    6200  106.19    7170  104.83
    7200  107.39    7250  117.22    7340   119.6    8060  123.87  8093.1  122.77
#Mann= 3 ,-1 , 0
  2838.3    .145       0  4953.4     .05       0  5046.6    .145       0
Bank Sta=4953.4,5046.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,117196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 135.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2118970.08       575988.22      2116476.92       575796.69
      2113762.48       576355.66
#Sta/Elev= 30
  2499.5   136.7  2599.5   136.6  2629.5  132.27  2769.5  131.15  2809.5  136.84
  3209.5  127.22  3319.5  118.98  3449.5   105.8  3619.5  103.34  4029.5  104.62
  4069.5  103.74  4659.5   104.3  4953.4   103.3  4955.9    98.3  5044.1    98.3
  5046.6   103.3    5670  105.32    6320  104.84    6360  105.76    6810     106
    6900  105.13    6930  106.47    6970  114.71    7030  118.35    7140  116.84
    7310  117.39    7470  113.63    7570  113.73    7580  115.04  7771.4  111.96
#Mann= 3 ,-1 , 0
  2499.5    .145       0  4953.4     .05       0  5046.6    .145       0
Bank Sta=4953.4,5046.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,116196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 134.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2119008.08       575810.83      2116614.62        574854.9
       2114041.2       573213.36
#Sta/Elev= 30
  2422.7  135.06  2502.7  136.32  2602.7  135.76  2772.7  133.02  2792.7  132.26
  2822.7  129.21  2842.7  130.68  2852.7  128.38  2862.7  130.19  2882.7   129.3
  3042.7  113.72  3122.7  107.27  3232.7   104.7  3452.7  102.93  3832.7  103.22
  3872.7  104.48  4951.3  102.93  4953.8   97.93  5046.2   97.93  5048.7  102.93
    6490  105.04    6590  114.87    7230  118.48    7600  117.32    7760  118.07
    7850  121.02    7880  120.16    8030  123.59    8040  125.25  8052.4  125.56
#Mann= 3 ,-1 , 0
  2422.7    .145       0  4951.3     .05       0  5048.7    .145       0
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,115196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 133.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2119476.85       575164.61      2117093.06       573990.62
      2114525.04       572525.02
#Sta/Elev= 30
  2342.8  120.92  2392.8  122.56  2502.8  122.31  2772.8  109.43  3062.8  107.46
  3192.8   104.5  3302.8   104.9  3422.8  102.61  3582.8  103.96  3602.8  102.59
  3702.8  102.29  3912.8   103.5  3992.8  102.37  4792.8  103.25  4951.3  102.29
  4953.8   97.29  5046.2   97.29  5048.7  102.29    5090  103.57    6530   103.5
    6570  104.16    6620  108.75    6710  111.51    6900  109.92    7050  112.76
    7460  113.04    7620  115.64    7810  114.28    7870  117.27  7956.8  118.16
#Mann= 3 ,-1 , 0
  2342.8    .145       0  4951.3     .05       0  5048.7    .145       0
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,114196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 132.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2120287.76       574721.14      2117718.64       573242.79
      2114636.44       571238.08
#Sta/Elev= 30
  2035.9   129.4  2125.9  128.76  2195.9  125.67  2265.9  126.54  2465.9  118.56
  2695.9  122.36  3405.9   102.3  4085.9  101.76  4115.9  104.24  4145.9  102.04
  4951.3  101.71  4953.8   96.71  5046.2   96.71  5048.7  101.71    5060  103.37
    7020  102.05    7160  103.46    7220  107.55    7310   109.4    7430  106.42
    7500  109.06    7610  108.11    7650  110.24    7910  109.76    8000  114.15
    8230   112.8    8540  117.47    8610   121.5    8620  119.92  8676.8  119.92
#Mann= 3 ,-1 , 0
  2035.9    .145       0  4951.3     .05       0  5048.7    .145       0
#XS Ineff= 2 , 0
       0                  7268.3       0  109.44
Permanent Ineff=
       F       F
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,113196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 131.0
END DESCRIPTION:
XS GIS Cut Line= 3
       2120908.7       573960.95      2118333.69       572456.87
      2115075.33        570469.9
#Sta/Elev= 30
  2017.9  127.43  2427.9  122.68  2537.9  116.43  2647.9  114.35  3147.9   112.9
  3257.9  111.64  3357.9  108.32  3407.9  109.41  3537.9  101.12  3937.9  101.14
  4027.9  102.33  4357.9  101.28  4817.9  102.26  4951.3  101.03  4953.8   96.03
  5046.2   96.03  5048.7  101.03    5280  102.11    7370  101.68    7440  105.97
    7560   108.6    7700  107.66    7820  110.38    8050  109.22    8200  110.66
    8330  109.34    8430  113.23    8530   112.9    8700  117.63  8816.4  118.32
#Mann= 3 ,-1 , 0
  2017.9    .145       0  4951.3     .05       0  5048.7    .145       0
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,112196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 130.0
END DESCRIPTION:
XS GIS Cut Line= 3
       2121238.1       573403.43      2118666.88       571525.99
       2115764.4       569399.51
#Sta/Elev= 30
  1816.3  125.31  2026.3  121.47  2316.3   113.6  2426.3  113.29  2686.3  106.89
  2916.3  106.69  3046.3  104.12  3266.3  106.07  3426.3  100.53  4446.3  101.62
  4936.3  101.25  4951.3  100.06  4953.8   95.06  5046.2   95.06  5048.7  100.06
    5070  101.35    6070  100.35    6170  101.34    6620  100.06    6750     102
    6830  100.96    7250  105.91    7470  106.07    7510  108.49    7600  110.93
    7740  109.36    7840   113.8    8140  117.41    8380  118.48  8598.1  115.34
#Mann= 3 ,-1 , 0
  1816.3    .145       0  4951.3     .05       0  5048.7    .145       0
#XS Ineff= 2 , 0
       0  3216.5  106.13               0
Permanent Ineff=
       F       F
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,111196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 129.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2121377.44       572643.16      2119126.14       570650.34
      2116676.65       568588.57
#Sta/Elev= 30
  1993.4  111.48  2283.4  112.74  2563.4  107.12  2663.4     108  2783.4  105.87
  2903.4  108.14  3023.4  106.05  3103.4  101.35  3153.4   100.4  3443.4  101.44
  3683.4  100.14  4253.4   99.95  4273.4     101  4951.3    99.7  4953.8    94.7
  5046.2    94.7  5048.7    99.7    6450  101.31    6660   99.73    6720   100.4
    6770  104.07    6830  105.84    6980  106.24    7170  104.01    7380  108.33
    7480  106.26    7640  106.11    7780  106.24    7950  109.21  8201.7  108.79
#Mann= 3 ,-1 , 0
  1993.4    .145       0  4951.3     .05       0  5048.7    .145       0
#XS Ineff= 2 , 0
       0                  6820.4       0  106.22
Permanent Ineff=
       F       F
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,110196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 128.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2121618.21       571971.65      2119845.56       569973.79
      2117639.68       567562.32
#Sta/Elev= 30
  2329.1  112.86  2419.1  113.66  2649.1  112.17  2879.1   105.7  2949.1  101.28
  3049.1    99.8  4579.1   99.54  4819.1  100.71  4951.3   98.96  4953.8   93.96
  5046.2   93.96  5048.7   98.96    5290  100.32    6140   99.19    6290   99.74
    6340   101.6    6610  100.74    6750   102.4    6850  101.21    7040  102.18
    7250     106    7530  104.36    7560  106.44    7820  110.52    7840  109.58
    7890  111.53    7920  110.58    7990  113.33    8130  113.54  8268.2  115.66
#Mann= 3 ,-1 , 0
  2329.1    .145       0  4951.3     .05       0  5048.7    .145       0
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,109196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 127.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2122413.27       571911.44      2120617.38       569345.83
      2118501.26       566928.77
#Sta/Elev= 30
  1868.3  114.36  2308.3  108.41  2528.3  108.65  2708.3  103.38  2838.3   103.2
  2958.3  100.76  3018.3  102.07  3048.3  100.52  3338.3  100.01  3418.3  102.25
  3458.3  100.13  3548.3   99.49  4678.3   99.97  4928.3   99.59  4951.3   98.47
  4953.8   93.47  5046.2   93.47  5048.7   98.47    5580   99.84    5770   98.53
    6450   98.54    6680  100.38    6770  102.51    7000  101.86    7160  103.39
    7280  105.48    7410  110.96    7520  111.55    7780  116.51  8212.5  113.07
#Mann= 3 ,-1 , 0
  1868.3    .145       0  4951.3     .05       0  5048.7    .145       0
#XS Ineff= 2 , 0
       0    3426  103.42  6775.5       0  103.42
Permanent Ineff=
       F       F
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,108196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 126.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2122777.58       571895.66      2121315.21       568632.34
      2119058.74       566371.24
#Sta/Elev= 30
    1424  111.29    1724  108.62    1834  103.76    2044  105.52    2104  103.63
    2224  104.63    2384   102.3    2454  102.43    2504  104.27    2714  100.62
  4951.3   97.97  4953.8   92.97  5046.2   92.97  5048.7   97.97    5370   98.26
    5490  100.22    5610   98.22    6030   97.97    6190   99.73    6250   98.42
    6470    98.3    6570   99.78    6660   98.49    6730    99.5    6810   98.29
    7190   99.33    7270   98.34    7390  102.81    7640  106.04  8194.4  106.14
#Mann= 3 ,-1 , 0
    1424    .145       0  4951.3     .05       0  5048.7    .145       0
Bank Sta=4951.3,5048.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,107196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 125.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2124820.72       570802.81      2122182.74        568150.1
      2119874.08       565841.35
#Sta/Elev= 30
  1258.9  115.24  1368.9  112.04  1468.9     114  1608.9  111.97  1658.9  113.24
  1798.9  109.84  2018.9  111.52  2208.9  104.34  2278.9  106.24  2378.9  103.58
  2608.9  104.89  2818.9  102.12  2938.9  104.44  3128.9   102.4  3268.9  104.58
  3458.9  103.31  3568.9   98.71  4949.8   97.51  4952.3   92.51  5047.7   92.51
  5050.2   97.51    5430   99.67    5850   97.51    7320   98.42    7410  103.94
    7560  107.28    7590  103.73    7630  104.04    7660  107.94    8265  117.43
#Mann= 3 ,-1 , 0
  1258.9     .14       0  4949.8     .05       0  5050.2     .14       0
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,106196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 124.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2124832.46        569435.6      2122750.65       567352.83
      2120370.18       564974.34
#Sta/Elev= 30
  2055.2   107.8  2265.2  106.76  2555.2  109.07  2775.2  106.01  2915.2  106.31
  3045.2  104.68  3075.2  105.67  3115.2  104.75  3175.2  100.14  3265.2   97.94
  3995.2   97.18  4415.2   98.86  4949.8   97.05  4952.3   92.05  5047.7   92.05
  5050.2   97.05    5990   97.39    6310    99.1    6610   97.05    6710   98.43
    7340   99.44    7430  100.44    7480  101.82    7500  103.72    7640  104.62
    7810  110.35    7930  116.34    8100  117.76    8190  120.57  8365.1  123.31
#Mann= 3 ,-1 , 0
  2055.2     .14       0  4949.8     .05       0  5050.2     .14       0
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,105196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 123.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2125327.49       568680.43       2123072.4       566416.13
      2120924.48       564261.59
#Sta/Elev= 30
  1804.3  108.91  2454.3  109.83  2624.3  106.47  2934.3  105.77  2994.3  104.25
  3044.3   99.06  3144.3   96.58  4949.8   96.52  4952.3   91.52  5047.7   91.52
  5050.2   96.52    5430    97.3    5460   99.98    5500   97.54    5670   96.58
    5850   98.18    6710   97.66    6850  104.98    6990  104.34    7010  105.95
    7060  114.94    7110  117.16    7130  121.39    7150  114.39    7180  112.57
    7260  115.27    7290  122.61    7330  123.79    7810  126.06  8042.3   124.2
#Mann= 3 ,-1 , 0
  1804.3     .14       0  4949.8     .05       0  5050.2     .14       0
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,104196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 122.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2126125.67       568082.93      2123902.53       565863.74
      2121594.53       563551.79
#Sta/Elev= 30
  1858.8  110.29  2138.8  110.59  2148.8  108.73  2178.8  111.02  2228.8   108.8
  2268.8  110.87  2398.8  110.17  2448.8  113.34  2518.8  108.66  2538.8  105.51
  2578.8  105.02  2598.8  107.43  2648.8  108.19  2918.8  109.92  3068.8  106.21
  3188.8   96.32  4448.8   97.66  4949.8   96.07  4952.3   91.07  5047.7   91.07
  5050.2   96.07    6180   96.23    6260   98.12    6730   98.78    6860  110.31
    6990  118.01    7220  121.18    7420  118.99    7660  125.63  8266.8  130.76
#Mann= 3 ,-1 , 0
  1858.8     .14       0  4949.8     .05       0  5050.2     .14       0
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,103196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 121.0
END DESCRIPTION:
XS GIS Cut Line= 3
       2126930.4       567517.78      2124749.16       565332.63
      2122437.57       563015.37
#Sta/Elev= 30
  1912.5  113.54  2112.5  110.72  2302.5  104.89  2882.5   108.2  3072.5   106.8
  3162.5  102.78  3202.5   96.38  4642.5   97.33  4662.5   96.06  4949.8   95.45
  4952.3   90.45  5047.7   90.45  5050.2   95.45    5230   97.12    6290   95.68
    6330   96.95    6580   95.45    6610   95.89    6640  100.67    6690   105.2
    6760  106.37    6850  111.35    6880  111.09    6900   113.2    7500  124.66
    7750  123.44    7780  124.84    7800  123.02    8230  122.07  8273.1  120.59
#Mann= 3 ,-1 , 0
  1912.5     .14       0  4949.8     .05       0  5050.2     .14       0
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,102196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 120.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2127639.28       566818.47      2125547.25       564732.91
      2123290.15       562469.34
#Sta/Elev= 30
    2046  111.35    2246  107.05    2356  102.09    2416  100.65    2626  104.32
    2856   99.56    3216   95.92    4516   95.84    4576   97.72    4636   95.46
    4916   96.41  4949.8   95.14  4952.3   90.14  5047.7   90.14  5050.2   95.14
    5060    96.3    5700   95.14    6730   95.97    6760  101.22    6800   99.05
    6860  106.14    6900  105.36    7270  113.29    7450  114.73    7760  111.27
    7920  113.15    7940  112.25    7960  113.29    8150   112.7  8196.6  113.56
#Mann= 3 ,-1 , 0
    2046     .14       0  4949.8     .05       0  5050.2     .14       0
#XS Ineff= 2 , 0
       0                  6760.3       0   101.7
Permanent Ineff=
       F       F
Bank Sta=4949.8,5050.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,101196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 119.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2128475.84       565962.25      2126194.17       563970.36
      2123839.54       561919.58
#Sta/Elev= 30
  1971.2  112.84  2421.2  105.91  2571.2  102.08  2631.2  103.02  2721.2   100.8
  2801.2   100.9  3011.2   95.56  3931.2   95.73  3951.2   97.59  4031.2   95.78
  4441.2   95.63  4471.2   97.37  4501.2   95.54  4601.2   94.75  4949.7   94.56
  4952.2   89.56  5047.8   89.56  5050.3   94.56    5500   96.31    5630   95.07
    5860   96.98    5880   95.29    5930    96.7    6080   95.05    7030   94.86
    7110   96.57    7220  107.18    7610  107.84    7940  113.19  8122.5  112.72
#Mann= 3 ,-1 , 0
  1971.2     .14       0  4949.7     .05       0  5050.3     .14       0
Bank Sta=4949.7,5050.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,100196  ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 118.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2129157.73       565275.34      2126842.03       563208.97
      2124410.93       561022.79
#Sta/Elev= 30
  1896.4  109.28  2276.4  109.64  2386.4  108.04  2406.4  107.02  3076.4     102
  3176.4   95.26  3216.4   94.64  4046.4   95.43  4256.4   94.32  4316.4   95.13
  4496.4   94.52  4716.4   95.27  4816.4   94.27  4906.4   95.55    4949   94.12
  4951.5   89.12  5048.5   89.12    5051   94.12    5060   95.15    5190   94.16
    6950   94.67    7040   96.19    7070   97.62    7080      99    7160   102.8
    7320  105.65    7600  105.75    7910  110.83    8190  108.25  8269.5  109.21
#Mann= 3 ,-1 , 0
  1896.4     .14       0    4949     .05       0    5051     .14       0
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,99196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 117.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2129746.46       564549.23      2127614.71         562593.
      2125173.99         560330.
#Sta/Elev= 30
  2106.7  109.99  2116.7  106.78  2166.7  106.66  2216.7  102.58  2366.7  101.77
  2406.7   100.3  2476.7  101.33  2496.7  100.76  2506.7   99.12  2926.7   97.97
  2946.7   97.02  2966.7   97.97  3126.7   96.15  3466.7   97.02  3646.7   94.04
  3676.7   95.76  3726.7   94.17  3926.7   95.09  4236.7   93.72    4949    93.6
  4951.5    88.6  5048.5    88.6    5051    93.6    5070   94.53    7330   94.41
    7340    94.8    7400  105.64    7410  106.03    7820   107.1  8328.4  103.66
#Mann= 3 ,-1 , 0
  2106.7     .14       0    4949     .05       0    5051     .14       0
#XS Ineff= 2 , 0
       0  3360.1   98.01               0
Permanent Ineff=
       F       F
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,98196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 116.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2130586.78       564116.42      2128480.05       562175.24
      2125602.41       559461.35
#Sta/Elev= 30
  2135.3  113.82  2195.3  112.72  2635.3  114.86  2825.3   110.2  2875.3  105.55
  2925.3  103.04  2965.3   98.53  3045.3   95.59  3065.3    96.3  3085.3   93.87
  3165.3   94.04  3195.3   95.94  3455.3   94.01  4135.3    95.9  4455.3   93.34
  4885.3   94.34    4949   92.94  4951.5   87.94  5048.5   87.94    5051   92.94
    5170   94.79    5220   93.38    7160   94.02    7280   92.94    7390   95.04
    7410   93.77    7700   93.88    8180   95.36    8300  104.66  8955.5  102.64
#Mann= 3 ,-1 , 0
  2135.3     .14       0    4949     .05       0    5051     .14       0
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,97196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 115.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2131380.09       563637.44      2129175.38        561577.5
      2125841.87       558503.36
#Sta/Elev= 30
  1982.7  108.71  2052.7  109.13  2142.7   104.7  2212.7  105.71  2742.7  102.78
  2802.7  103.73  2942.7  101.86  3102.7   95.88  3192.7   95.83  3292.7    93.2
  3312.7    94.7  3362.7   93.43  4032.7   94.33  4162.7   92.68  4432.7   94.21
    4949   92.58  4951.5   87.58  5048.5   87.58    5051   92.58    6120   94.14
    7860   93.06    7950   95.01    8100   94.33    8160   99.01    8350  101.67
    8550   101.2    8810   96.99    8980   98.32    9000  100.07  9534.6  103.15
#Mann= 3 ,-1 , 0
  1982.7     .14       0    4949     .05       0    5051     .14       0
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,96196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 114.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2132158.44       563158.47      2130105.11       561361.81
      2126216.13       557889.72
#Sta/Elev= 30
  2271.6   105.8  2391.6  105.32  2461.6  102.06  2531.6  102.18  2621.6  106.33
  2791.6  101.26  3051.6  101.07  3091.6    98.2  3251.6    96.1  3341.6   97.45
  3361.6   94.79  3411.6   94.03  4051.6   95.19  4181.6   93.01  4321.6   94.43
    4949   92.09  4951.5   87.09  5048.5   87.09    5051   92.09    5140   94.15
    5290    92.1    8150   92.42    8330   93.35    8370   96.39    8460    98.2
    8830   98.81    9010   95.13    9330   95.51    9820  102.26 10213.4  102.98
#Mann= 3 ,-1 , 0
  2271.6     .14       0    4949     .05       0    5051     .14       0
#XS Ineff= 2 , 0
       0  3330.5   97.71  8454.3       0   98.52
Permanent Ineff=
       F       F
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,95196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 113.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2132951.74       562664.52      2130860.69       560905.99
      2126665.18       557350.87
#Sta/Elev= 30
  2267.8  105.14  2457.8  107.74  2677.8  103.49  2957.8  104.87  3107.8  102.32
  3377.8  105.19  3547.8  103.46  3727.8   98.28  3797.8   93.54  3867.8   92.39
  4387.8   93.58  4937.8   93.05    4949    91.6  4951.5    86.6  5048.5    86.6
    5051    91.6    5240   93.15    6050    91.6    7520   93.19    7770   91.64
    7890    93.1    8460   91.91    8690   96.29    9030   93.56    9250   97.02
    9590   97.63    9950  101.19   10280  101.57   10370   99.84 10499.2  102.42
#Mann= 3 ,-1 , 0
  2267.8     .14       0    4949     .05       0    5051     .14       0
#XS Ineff= 2 , 0
       0                    8709       0   96.78
Permanent Ineff=
       F       F
Bank Sta=4949,5051
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,94196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 112.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2133602.67       561963.72      2131411.69       560092.95
      2127396.43       556714.18
#Sta/Elev= 30
    2119  108.27    2419  107.07    2769   110.6    2899  108.73    3049  100.39
    3119  100.28    3219  103.57    3299  100.92    3399  101.51    3469    97.9
    3699   95.38    3889   96.25  4948.7   90.91  4951.2   85.91  5048.8   85.91
  5051.3   90.91    5060   92.51    5470   90.91    7760    92.8    8000   91.22
    8080   93.17    8200    91.3    8360   93.52    8410   91.72    8450   93.21
    8990   92.09    9640   98.13    9930      96    9990   98.28 10247.7  100.33
#Mann= 3 ,-1 , 0
    2119     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0  3886.9   96.73  9359.3       0   96.53
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,93196   ,999,999,999
BEGIN DESCRIPTION:
Four Hole Swamp 111.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2134215.94        561301.4      2132013.96       559383.83
      2128156.92       555831.11
#Sta/Elev= 30
  2080.1  106.83  2250.1  108.59  2520.1   106.3  2710.1  100.97  3060.1  101.17
  3300.1   97.86  3420.1   99.36  3590.1    95.4  3910.1   96.54  4020.1   91.42
  4770.1   92.21  4948.7   90.49  4951.2   85.49  5048.8   85.49  5051.3   90.49
    5160   92.03    6050   90.49    7090   92.24    8490   90.64    9010   97.74
    9140   94.24    9280   98.11    9360   97.29    9480   99.85    9770   95.62
   10110  100.94   10140   98.28   10160  103.07   10200   96.97 10243.9   96.76
#Mann= 3 ,-1 , 0
  2080.1     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0  3912.9   97.13  8942.7       0   97.69
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,92197   ,1066,1066,1066
BEGIN DESCRIPTION:
Four Hole Swamp 110.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2134742.74       560628.75      2132799.88       558908.84
        2128417.       555388.44
#Sta/Elev= 30
  2471.7  104.17  2501.7  105.95  2571.7  102.37  3271.7   97.78  3461.7  100.01
  3541.7   95.25  3671.7   97.42  3821.7   93.89  4061.7   95.92  4371.7   90.65
  4948.7   89.69  4951.2   84.69  5048.8   84.69  5051.3   89.69  5066.5   91.66
  6286.5   89.96  6346.5   93.58  6376.5   90.91  6526.5   90.28  8446.5   92.04
  8956.5   90.11  9126.5   90.58  9266.5   96.05  9486.5   92.27  9626.5   96.01
 10146.5   96.28 10166.5   99.59 10386.5    98.3 10516.5  101.81 10688.1  101.93
#Mann= 3 ,-1 , 0
  2471.7     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0  4070.8   96.61  9258.3       0   96.54
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,91131   ,106,106,106
BEGIN DESCRIPTION:
Farm Road - US
END DESCRIPTION:
XS GIS Cut Line= 5
      2135438.15       559782.76      2133806.67       558148.61
      2133500.66       558149.17      2133191.49       558149.81
      2128514.76       555318.93
#Sta/Elev= 30
  2387.1  101.77  2737.1   99.31  2957.1  101.18  3087.1   94.86  3107.1   98.27
  3167.1   99.12  3197.1   98.23  3217.1   95.01  3767.1   96.07  3917.1   92.42
  4077.1   93.51  4257.1   90.43    4977   89.19    4979    85.2    5021    85.2
    5023   89.24  5302.3   90.26  5361.4   93.04  5451.4   90.14  5721.4   91.38
  5801.4   89.39  6531.4   91.46  6851.4   89.71  9151.4   90.14  9481.4    91.6
  9641.4    96.2 10141.4   96.33 10171.4   94.68 10191.4   97.56 10778.2  101.86
#Mann= 3 ,-1 , 0
  2387.1     .14       0    4977     .05       0    5023     .14       0
#XS Ineff= 2 , 0
       0  3822.5   96.33  9656.4       0   96.61
Permanent Ineff=
       F       F
Bank Sta=4977,5023
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 3 ,91088   ,,,
BEGIN DESCRIPTION:
Farm Road - TOR
Structure ID: LDS_FHS_05
Approximate Survey Structure
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
39,8,3,0, 301, 301, , , 0.95, 0, 1,1,,
  2329.3  2469.3  2479.3  2509.3  2529.3  2589.3  2609.3  2639.3  2669.3  2679.3
  2689.3  2699.3  2729.3  2739.3  2749.3  2779.3  2849.3  2859.3  2909.3  2919.3
  2929.3  2939.3  2959.3  2979.3  2989.3  3009.3  3189.3  3199.3  3209.3  3219.3
  3239.3  3299.3  3369.3  3379.3  3389.3  3419.3  3439.3  3519.3  3529.3  3739.3
  3749.3  3759.3  3769.3  3779.3  3789.3  3839.3  3849.3  3879.3  3889.3  3919.3
  3929.3  3979.3  4029.3  4039.3  4059.3  4069.3  4139.3  4149.3  4169.3  4179.3
  4189.3  4219.3  4229.3  4249.3  4289.3  4299.3  4309.3  4339.3  4349.3  4509.3
  4519.3  4529.3  4539.3  4549.3  4559.3  4569.3  4609.3  4619.3  4639.3  4659.3
  4669.3  4679.3  4686.2  4866.2    4975    4975    5025    5025  5061.2  5071.2
  5081.2  5101.2  5121.2  5201.2  5211.2  5221.2  5231.2  5241.2  5251.2  5301.2
  5328.2  5338.2  5348.2  5358.2  5378.2  5398.2  5488.2  5498.2  5548.2  5578.2
  5588.2  5628.2  5638.2  5648.2  5698.2  5708.2  5718.2  5728.2  5758.2  5768.2
  5788.2  5838.2  5858.2  5868.2  5888.2  5898.2  5908.2  5918.2  5948.2  6058.2
  6078.2  6138.2  6148.2  6158.2  6178.2  6208.2  6228.2  6248.2  6268.2  6278.2
  6288.2  6308.2  6318.2  6328.2  6338.2  6388.2  6408.2  6448.2  6508.2  6518.2
  6528.2  6568.2  6598.2  6608.2  6618.2  6638.2  6778.2  6788.2  6798.2  6838.2
  6848.2  6858.2  6998.2  7018.2  7028.2  7068.2  7118.2  7128.2  7188.2  7208.2
  7218.2  7228.2  7268.2  7338.2  7518.2  7528.2  7558.2  7568.2  7578.2  7608.2
  7628.2  7648.2  7678.2  7698.2  7718.2  7758.2  7768.2  7838.2  7848.2  7858.2
  7868.2  7918.2  7938.2  8018.2  8028.2  8038.2  8128.2  8138.2  8158.2  8178.2
  8198.2  8208.2  8228.2  8238.2  8248.2  8258.2  8308.2  8328.2  8338.2  8348.2
  8358.2  8408.2  8418.2  8428.2  8458.2  8468.2  8478.2  8488.2  8498.2  8508.2
  8518.2  8528.2  8558.2  8588.2  8638.2  8678.2  8718.2  8738.2  8758.2  8768.2
  8788.2  8798.2  8808.2  8818.2  8828.2  8838.2  8928.2  8948.2  8958.2  8968.2
  8978.2  8988.2  9018.2  9028.2  9058.2  9068.2  9088.2  9098.2  9128.2  9178.2
  9208.2  9238.2  9248.2  9298.2  9308.2  9318.2  9348.2  9358.2  9378.2  9388.2
  9408.2  9418.2  9428.2  9438.2  9448.2  9458.2  9508.2  9518.2  9528.2  9538.2
  9568.2  9578.2  9608.2  9648.2  9658.2  9678.2  9688.2  9698.2  9708.2  9718.2
  9858.2  9888.2  9938.2  9948.2  9958.2  9978.2  9988.2  9998.2 10018.2 10058.2
 10098.2 10108.2 10118.2 10138.2 10148.2 10158.2 10168.2 10178.2 10188.2 10268.2
 10793.4
  101.73  101.08  100.78  100.48  100.62   99.15   99.37   97.95   98.73   98.46
   98.55   98.97   99.19   98.94   99.24    99.4  100.23  100.66   100.3  100.79
  100.77  100.15   99.57   99.65     100  100.19   99.06   98.16   96.24   95.41
      95   95.59   94.75   96.12   96.61   96.03   94.86   94.83   95.24    96.1
   96.53   96.26   95.52   96.06   96.05   95.32   94.76   94.07   94.17   93.36
   93.39   92.41   92.27   91.95   92.38   91.97   91.65   91.33   91.33   90.81
   91.06   90.59   90.76   90.26   90.15   90.49   90.22   90.09   90.45   90.59
   89.98   90.14   90.61   90.24   90.37   90.14   90.31   90.77   89.83    89.9
   90.48   91.95   92.59   92.58   92.05   92.05   92.05   92.05   91.69   91.63
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BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,0.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=102.01
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,91025   ,675,675,675
BEGIN DESCRIPTION:
Farm Road - DS
END DESCRIPTION:
XS GIS Cut Line= 5
      2135533.14       559751.12      2133836.04       558053.83
      2133543.85       558054.24      2133193.31       558053.42
      2128525.23       555260.54
#Sta/Elev= 30
  2314.1  102.36  2644.1   98.26  2894.1  100.63  3204.1   98.94  3244.1   95.05
  3774.1   96.68  3974.1   92.46  4294.1   90.02  4624.1   89.74  4654.1   92.62
  4744.3    89.6    4977   89.75    4979   85.29    5021   85.29    5023    89.7
  5026.5   92.04  5066.5   89.85    5457   89.66    5507   92.53    5547   90.41
    5767   89.54    8217   91.56    9087   89.91    9467   91.67    9607   95.62
   10017    94.8   10147    96.3   10167   99.03   10237   97.33 10796.8  101.31
#Mann= 3 ,-1 , 0
  2314.1     .14       0    4977     .05       0    5023     .14       0
#XS Ineff= 2 , 0
       0  3829.2   96.71  9597.8       0    96.4
Permanent Ineff=
       F       F
Bank Sta=4977,5023
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,90350   ,154,154,154
BEGIN DESCRIPTION:
Vance Road - US
END DESCRIPTION:
XS GIS Cut Line= 6
      2135557.26       559100.59      2135375.45       558632.42
      2135080.68       558157.52      2134842.43       557959.57
      2134575.79       557777.67      2128696.24       555110.14
#Sta/Elev= 30
  2504.2   98.78  2804.2   98.36  2884.2   93.91  2944.2   93.54  3745.4   92.45
  3765.4   93.89  3895.1   90.91  4197.9   89.33    4925   89.23    4935    84.1
    5065    84.1    5075   89.16  6005.2   91.08  6125.2   89.68  7685.2    89.3
  8425.2   90.98  8565.2   89.45  8705.2   91.37  9045.2    90.6  9065.2   92.59
  9185.2   94.01  9445.2      94  9605.2   96.15  9745.2   93.87  9945.2   94.23
 10045.2      98 10345.2   98.84 10425.2   93.43 10445.2   95.89 10654.3  100.95
#Mann= 3 ,-1 , 0
  2504.2     .14       0    4925     .05       0    5075     .14       0
#XS Ineff= 2 , 0
       0    4901    98.5    5099       0    98.5
Permanent Ineff=
       F       F
Bank Sta=4925,5075
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 3 ,90266   ,,,
BEGIN DESCRIPTION:
Vance Road - TOR
Structure ID: LDS_FHS_04
Approximate Survey Structure
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
65,38,3,0, 23, 23, , , 0.95, 0, 1,1,,
  2019.8  2950.1  3359.5  4037.5  4861.6  4926.5  4926.5  5073.5  5073.5  5138.9
    6566    6586    6726    6746    6766    7266    7286    7306    7326    7346
    7366 10331.8 10723.4
  101.39   99.03      99   98.87   98.51   98.51   98.51   98.51   98.51   98.51
    98.5   89.63   89.81   94.55   98.32   98.35   95.14   90.96   91.24    94.5
   98.43   98.88    99.9
   65.31   65.31   65.31   65.31   65.31   65.31   97.21   97.21   65.31   65.31
   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31
   65.31   65.31   65.31
  2019.8  2950.1  3359.5  4037.5  4861.6  4926.5  4926.5  5073.5  5073.5  5138.9
    6566    6586    6726    6746    6766    7266    7286    7306    7326    7346
    7366 10331.8 10723.4
  101.39   99.03      99   98.87   98.51   98.51   98.51   98.51   98.51   98.51
    98.5   89.63   89.81   94.55   98.32   98.35   95.14   90.96   91.24    94.5
   98.43   98.88    99.9
   65.31   65.31   65.31   65.31   65.31   65.31   97.21   97.21   65.31   65.31
   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31   65.31
   65.31   65.31   65.31
Pier Skew, UpSta & Num, DnSta & Num=  ,4938.8, 2 ,4938.8, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Pier Skew, UpSta & Num, DnSta & Num=  ,4963.3, 2 ,4963.3, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Pier Skew, UpSta & Num, DnSta & Num=  ,4987.8, 2 ,4987.8, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Pier Skew, UpSta & Num, DnSta & Num=  ,5012.3, 2 ,5012.3, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Pier Skew, UpSta & Num, DnSta & Num=  ,5036.8, 2 ,5036.8, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Pier Skew, UpSta & Num, DnSta & Num=  ,5061.3, 2 ,5061.3, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   85.31   97.21
     1.5     1.5
   85.06   97.21
Abutment Skew #Up #Dn= , 2 , 2
  4926.5    4935
   97.21   85.31
  4926.5    4935
   97.21   85.06
Abutment Skew #Up #Dn= , 2 , 2
    5065  5073.5
   85.31   97.21
    5065  5073.5
   85.06   97.21
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,0.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=100.95
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,90196   ,1000,1000,1000
BEGIN DESCRIPTION:
Vance Road - DS
END DESCRIPTION:
XS GIS Cut Line= 6
      2135733.15       559071.27      2135426.47        558313.6
      2135223.52       558031.73      2134921.35       557767.89
      2132925.72       556836.66      2128774.66       554963.94
#Sta/Elev= 30
  2322.1   98.57  2622.1   95.53  3239.5   96.84  3299.5   94.71  3319.5   97.06
  3459.5   93.02  3479.5   94.82  3586.8   91.96    4068   89.17  4581.3   92.09
    4925   89.15    4935      84    5065      84    5075   89.13  5819.9   91.38
    6431   89.43    7371   89.46    7431   91.39    7771   89.11    8171   91.53
    8591   89.39    8931   90.23    9011    93.6    9291   91.79    9311   94.08
    9351   90.67    9851   91.21    9991   94.16   10511   93.71 10644.9   99.21
#Mann= 3 ,-1 , 0
  2322.1     .14       0    4925     .05       0    5075     .14       0
#XS Ineff= 2 , 0
       0  4903.4    98.5  5096.6       0    98.5
Permanent Ineff=
       F       F
Bank Sta=4925,5075
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,89196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 107.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2136678.75       557994.45      2134673.88       556711.16
      2129142.66       553945.77
#Sta/Elev= 30
  2619.6   98.21  2679.6   98.84  2719.6   96.28  2739.6   98.74  3819.6   95.28
  3859.6   94.04  3899.6   89.09  3979.6   88.71  4419.6   90.24  4948.7   88.47
  4951.2   83.47  5048.8   83.47  5051.3   88.47    5960   89.06    6140   91.14
    6580   88.89    7820    88.8    7880   90.65    8140   88.92    8420   89.61
    8540   92.96    8620   89.42    9400   89.17    9460   93.01    9620   88.47
    9760   92.27   10060   90.25   10380   96.72   10600    92.8   11184   95.27
#Mann= 3 ,-1 , 0
  2619.6     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0                  8501.5       0   94.08
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,88196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 106.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2137772.92       557793.57       2135036.1       555835.41
      2129389.33       553040.04
#Sta/Elev= 30
  1634.8   99.67  3034.8    94.2  3674.8   88.12  4754.8   89.65  4948.7   88.03
  4951.2   83.03  5048.8   83.03  5051.3   88.03    5560   89.93    5960   88.22
    8740   88.36    8940   90.28    9020   88.09    9120   91.23    9200    88.5
    9440   88.03    9460    89.7    9500   88.12    9620   92.18    9700   89.81
    9800   92.01   10280    92.7   10580    96.9   10800   94.82   10820   90.76
   10900   89.77   10960   91.81   11200    89.8   11240   94.14 11300.8   92.71
#Mann= 3 ,-1 , 0
  1634.8     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0                  9111.4       0   93.23
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,87196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 105.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2138508.78       557499.17      2135102.31       554856.58
      2130364.62       552200.56
#Sta/Elev= 30
   688.7   98.91   948.7   99.55  1128.7    97.3  2748.7   93.25  2848.7   92.24
  2948.7   87.74  4208.7   89.09  4348.7   87.78  4488.7   89.73  4948.7   87.71
  4951.2   82.71  5048.8   82.71  5051.3   87.71    5240   89.44    5560    87.9
    6580   89.38    6980   88.03    7460   89.47    9140   88.85    9200   90.69
    9440   89.98    9480   91.45    9680   90.67    9720   92.17    9760      90
    9880   89.47    9960   92.47   10000   91.39   10200   93.63 10431.4   92.35
#Mann= 3 ,-1 , 0
   688.7     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0                  9210.5       0   92.04
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,86196   ,1000,1000,1000
BEGIN DESCRIPTION:
Four Hole Swamp 104.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2139134.02       557221.31      2135428.17       553931.08
      2130487.32       551832.63
#Sta/Elev= 30
    44.3   97.22  1104.3   94.59  1384.3   95.34  1944.3   92.06  2124.3   92.14
  2144.3   93.56  2244.3   88.43  2384.3   87.46  4764.3   87.71  4884.3   89.16
  4948.7   86.96  4951.2   81.96  5048.8   81.96  5051.3   86.96    5060   88.09
    5700   88.75    6180   87.47    6360   88.72    8620   87.82    8960   88.39
    9000   90.85    9140   91.75    9260    90.2    9440   92.16    9500   90.02
    9760   91.92    9880   89.72    9960   92.24   10100   90.54   10368   92.69
#Mann= 3 ,-1 , 0
    44.3     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0                  9084.1       0   92.89
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,85196   ,3000,3000,3000
BEGIN DESCRIPTION:
Four Hole Swamp 103.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2139787.21       557221.26      2136065.72       553245.02
      2130683.58       551489.21
#Sta/Elev= 30
  -446.1   97.87  -166.1    95.3  1313.9   92.27  1653.9   94.01  1833.9   91.64
  2013.9   92.49  2133.9   87.46  3313.9    88.2  4053.9   86.67  4393.9      87
  4453.9   88.57  4513.9   86.58  4948.7   86.14  4951.2   81.14  5048.8   81.14
  5051.3   86.14    6140   88.19    9180   88.22    9400   88.52    9560   92.09
    9640   90.25    9720   91.91   10000   91.12   10040   88.65   10100   88.47
   10240   89.96   10260   93.36   10280   91.75   10520   90.37 10661.3   91.18
#Mann= 3 ,-1 , 0
  -446.1     .14       0  4948.7     .05       0  5051.3     .14       0
#XS Ineff= 2 , 0
       0                  9556.6       0   92.66
Permanent Ineff=
       F       F
Bank Sta=4948.7,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,82196   ,1347,1347,1347
BEGIN DESCRIPTION:
Four Hole Swamp 100.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2140288.04       557373.69      2138027.62       551677.07
      2135258.09       545158.08
#Sta/Elev= 30
 -1128.7   98.02  1131.3   91.85  1211.3   88.72  1351.3   90.99  1411.3   87.39
  1591.3   91.45  2151.3   86.14  4937.7   84.55  4940.2   79.55  5059.8   79.55
  5062.3   84.55    9100   86.29    9420   92.58    9480   89.42    9820   94.14
   10160   91.77   10260   94.81   11440   94.93   11500   98.93   11520   95.65
   11600   95.22   11620   99.39   11640   95.58   11740   96.15   11760   99.73
   11780   96.29   11860   96.67   11880  100.52   11900   96.22 12082.9   97.11
#Mann= 3 ,-1 , 0
 -1128.7     .14       0  4937.7     .05       0  5062.3     .14       0
#XS Ineff= 2 , 0
       0  1744.6   92.27  9368.4       0   92.54
Permanent Ineff=
       F       F
Bank Sta=4937.7,5062.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,80849   ,1163,1163,1163
BEGIN DESCRIPTION:
Four Hole Swamp 99.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2141398.56       557591.43      2139351.74       551472.75
      2136542.79       544548.36
#Sta/Elev= 30
 -1451.7   96.87   148.3   91.71   728.3   92.93   868.3   89.37  1408.3   92.66
  1608.3   88.67  1848.3   87.95  1988.3   91.07  2168.3   89.64  2308.3   84.95
  3868.3   86.37  4937.7   83.97  4940.2   78.97  5059.8   78.97  5062.3   83.97
  6540.3   86.55  6680.3   84.18  7300.3      84  7420.3   86.32  7480.3   84.13
  8780.3   84.57  8860.3   88.61  9000.3   90.44  9120.3   87.22 11420.3    96.2
 11600.3   93.54 11960.3   95.79 12020.3  100.03 12080.3   95.71 12472.7   95.94
#Mann= 3 ,-1 , 0
 -1451.7     .14       0  4937.7     .05       0  5062.3     .14       0
#XS Ineff= 2 , 0
       0  2076.5    90.8  9000.5       0   91.04
Permanent Ineff=
       F       F
Bank Sta=4937.7,5062.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,79686   ,949,949,949
BEGIN DESCRIPTION:
Four Hole Swamp 98.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2142334.88       557591.45      2140462.25       551124.35
      2137805.74        544112.9
#Sta/Elev= 30
 -1758.4   95.41 -1498.4   94.96 -1398.4   91.76 -1378.4   93.93  -718.4   93.95
   341.6   90.37   501.6   93.03   661.6   88.55   741.6   91.41  1021.6   91.58
  1261.6   88.07  1441.6   89.65  2041.6    84.6  3801.6   85.49  3881.6   83.51
  4821.6   85.34  4937.7    83.4  4940.2    78.4  5059.8    78.4  5062.3    83.4
  5734.4   85.65  5954.4   83.92  8754.4   83.82  8914.4   88.15  9914.4   88.49
 10174.4    91.2 10214.4   89.65 11114.4   91.73 11554.4   95.29 12472.2    96.6
#Mann= 3 ,-1 , 0
 -1758.4     .14       0  4937.7     .05       0  5062.3     .14       0
#XS Ineff= 2 , 0
       0  1450.6   90.89 10058.7       0   91.25
Permanent Ineff=
       F       F
Bank Sta=4937.7,5062.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,78737   ,1051,1051,1051
BEGIN DESCRIPTION:
Four Hole Swamp 97.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2143205.87       557591.45      2141376.79       550884.83
      2138720.28       543786.29
#Sta/Elev= 30
 -1953.9   94.57 -1733.9   93.39 -1493.9      96  -873.9   94.23  -793.9   91.62
   686.1   90.62  1046.1   85.49  4937.7   82.77  4940.2   77.77  5059.8   77.77
  5062.3   82.77  5757.7   85.17  6737.7   83.15  8917.7   83.55  9017.7   86.81
  9177.7   87.83  9297.7   86.21  9377.7   88.93  9777.7   87.78  9917.7   88.24
  9937.7    90.1 10197.7   88.46 10257.7   90.43 10337.7   88.54 10517.7   90.76
 11857.7   94.16 11937.7   96.18 12057.7   93.78 12177.7   95.73   12577   96.29
#Mann= 3 ,-1 , 0
 -1953.9     .14       0  4937.7     .05       0  5062.3     .14       0
#XS Ineff= 2 , 0
       0                  9944.6       0   90.79
Permanent Ineff=
       F       F
Bank Sta=4937.7,5062.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,77686   ,234,234,234
BEGIN DESCRIPTION:
Highway I-95 South - US
END DESCRIPTION:
XS GIS Cut Line= 6
      2144491.44       557235.23      2143560.98       553775.56
      2142318.52        550453.3      2141101.22       547368.38
      2140746.29       546403.42      2139686.94       543685.33
#Sta/Elev= 30
   -2134   90.88    -974   90.44    -654   86.83    -534   89.74    -494   86.91
    -434    89.5     346   85.31     766   85.23     826   86.88     946    83.6
    1446    82.5  2828.6   83.88  4888.5   82.26  4917.5   77.55  5082.5   77.55
  5111.5   82.28  8235.6   82.78    8432   85.93  9660.2   87.41  9720.2   89.25
 10020.2   90.76 10060.2   88.98 10800.2   89.98 10840.2   92.17 11100.2   91.09
 11220.2   94.03 11300.2   92.32 11720.2   95.15 11820.2   92.87 12257.4   90.81
#Mann= 3 ,-1 , 0
   -2134    .145       0  4888.5     .05       0  5111.5    .145       0
#XS Ineff= 2 , 0
       0  4854.3    92.7  5145.7       0    92.7
Permanent Ineff=
       F       F
Bank Sta=4888.5,5111.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 3 ,77544   ,,,
BEGIN DESCRIPTION:
Highway I-95 South - TOR
Structure ID: LDS_FHS_02
Approximate Survey Structure
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
123,38,3,0, 25, 25, , , 0.95, 0, 1,1,,
 -2208.2  1322.1  1342.1  1362.1  1382.1  1422.1  1442.1  1462.1  1482.1  1544.4
  4769.3  4882.5  4882.5  5117.5  5117.5  5238.4  7241.9  7279.2  7299.2  7319.2
  7479.2  7499.2  7519.2   11418 12227.5
   92.62   92.25   89.73   84.43   81.84   81.68   82.59   84.71   89.95    92.2
   92.69   92.69   92.69   92.69   92.69   92.69   92.81   91.78   85.81   82.75
   82.45   87.28   92.85   99.97  100.51
   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59
   60.59   60.59   91.09   91.09   60.59   60.59   60.59   60.59   60.59   60.59
   60.59   60.59   60.59   60.59   60.59
 -2208.2  1322.1  1342.1  1362.1  1382.1  1422.1  1442.1  1462.1  1482.1  1544.4
  4769.3  4882.5  4882.5  5117.5  5117.5  5238.4  7241.9  7279.2  7299.2  7319.2
  7479.2  7499.2  7519.2   11418 12227.5
   92.62   92.25   89.73   84.43   81.84   81.68   82.59   84.71   89.95    92.2
   92.69   92.69   92.69   92.69   92.69   92.69   92.81   91.78   85.81   82.75
   82.45   87.28   92.85   99.97  100.51
   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59   60.59
   60.59   60.59   91.09   91.09   60.59   60.59   60.59   60.59   60.59   60.59
   60.59   60.59   60.59   60.59   60.59
Pier Skew, UpSta & Num, DnSta & Num=  ,4899.3, 2 ,4899.3, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   86.68   91.09
     1.5     1.5
   86.43   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,4932.9, 2 ,4932.9, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   80.59   91.09
     1.5     1.5
   80.34   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,4966.4, 2 ,4966.4, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   80.59   91.09
     1.5     1.5
   80.34   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5000, 2 ,5000, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   80.59   91.09
     1.5     1.5
   80.34   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5033.6, 2 ,5033.6, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   80.59   91.09
     1.5     1.5
   80.34   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5067.1, 2 ,5067.1, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   80.59   91.09
     1.5     1.5
   80.34   91.09
Pier Skew, UpSta & Num, DnSta & Num=  ,5100.7, 2 ,5100.7, 2 , 0 , 0 , 0 ,0,0
     1.5     1.5
   86.68   91.09
     1.5     1.5
   86.43   91.09
Abutment Skew #Up #Dn= , 2 , 2
  4882.5    4900
   91.09   86.44
  4882.5    4900
   91.09   86.19
Abutment Skew #Up #Dn= , 2 , 2
    5100  5117.5
   86.44   91.09
    5100  5117.5
   86.19   91.09
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,0.8,0,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=95.15
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0
